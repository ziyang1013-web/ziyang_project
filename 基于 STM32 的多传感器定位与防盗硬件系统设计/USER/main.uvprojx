# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MyCode\led;..\MyCode\Buzzer;..\MyCode\HX711;..\MyCode\OLED;..\MyCode\USART2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MyCode
    ../MyCode/led/: LED.c beep.c beep.h
    ../MyCode/USART2/: USART2.c USART2.h Key.c Key.h
    ../MyCode/OLED/: FSR402.c FSR402.h oled.c oled.h oledfont.h bmp.h dht11.c dht11.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c
    ../STM32_FWLIB/inc/: stm32f10x_adc.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c adcx.c adcx.h
software components: CMSIS:CORE 5.2.0
